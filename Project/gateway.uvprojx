# Keil uVision project gateway.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\User;..\User\ESP8266;..\User\SysTick;..\User\usart;..\User\Common;..\User\ZigBeeGS;..\User\ZigBeeSLC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c
    ../User/ESP8266/: bsp_esp8266.c
    ../User/Common/: Common.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/ZigBeeSLC/: zigbeeSLC_usart.c
    ../User/ZigBeeGS/: zigbeeGS_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Doc
    ../Doc/: Readme.txt
software components: CMSIS:CORE 4.1.0
